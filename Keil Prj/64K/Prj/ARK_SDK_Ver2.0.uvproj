# Keil uVision project ARK_SDK_Ver2.0.uvproj, settings and files
target ARK-SDK (MCS-51)
  device: AT89S53 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: AMT_CAR_HEX +hex
  BeforeMake: ..\..\..\PC Tool\18X9_Function_Location "\\List"
  AfterMake: ..\..\..\PC Tool\18X9_Function_Location "\\List"
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\OSD;..\..\..\OSD\Logo;../../../Inc;../../../UserConfig;../../../ARKLib;../../../UserConfig/Prj config;..\..\..\LCD Pannels;..\..\..\LCD Pannels\LCD parameter;..\..\..\GetUserInput;..\..\..\GetUserInput\Ir;..\..\..\GetUserInput\Key;..\..\..\GetUserInput\GPIO;..\..\..\Device driver\AMT;..\..\..\Device driver\ArkChip;..\..\..\Device driver\Mcu;..\..\..\Device driver\Flash;..\..\..\Device driver\I2C;..\..\..\Device driver\E2prom;..\..\..\Device driver\WT5700;..\..\..\Device driver\Kt0803l;..\..\..\Device driver\BT;..\..\..\Debug;..\..\..\Device driver\SPI;..\..\..\Device driver\RX5808;..\..\..\FPVGoggles
  group ARKLib
    ../../../ARKLib/: AMTIOLib.LIB SPI.LIB AMT630A_VIDEO_LIB_V1.0.7.LIB
  group LCD Pannels
    ../../../LCD Pannels/: ConfigLcdPara.c Uart_AdjSpiReg.c
  group Device driver
    ../../../Device driver/ArkChip/: ArkChip.c
    ../../../Device driver/Mcu/: Mcu.c
    ../../../Device driver/E2prom/: E2prom.c
    ../../../Device driver/Flash/: Flash.c
    ../../../Device driver/I2C/: E2pI2C.c KeyI2C.c Kt0803lI2C.c
    ../../../Device driver/WT5700/: WT5700.c
    ../../../Device driver/Kt0803l/: Kt0803l.c
    ../../../Device driver/BT/: BT_UartRec.c
    ../../../Device driver/SPI/: SPI.c
    ../../../Device driver/RX5808/: rx_5808.c
  group Kenel
    ../../../Kernel/: Main.c Global.c GetSysMsg.c Delay.c Interrupt.c EventHandle.c
  group GetUserInput
    ../../../GetUserInput/: GetUserInputMsg.c
    ../../../GetUserInput/Key/: AdcKeyPad.c TouchKeyPad.c
    ../../../GetUserInput/Ir/: Ir.c
  group Modules
    ../../../Modules/: SysPower.c SysWorkPara.c VideoProc.c BatteryAdc.c
  group OsdFont
    ../../../OSD/: Osd_AMT630FontLib.c Osd_GeneralFontDat.c
  group Menu
    ../../../OSD/: Osd_PowerOnMenu.c Osd_PowerOffMenu.c Osd_RootMenu.c Osd_LogoMenu.c Osd_BatteryAdcMenu.c Osd_NoSignalMenu.c Osd_BTMenu.c Osd_BTCallerMenu.c Osd_QuicklySourceMenu.c Osd_QuicklyMuteMenu.c Osd_BrightnessMenu.c Osd_ContrastMenu.c Osd_SaturationMenu.c Osd_TintMenu.c Osd_VolumeMenu.c Osd_ModeMenu.c Osd_SysMenu.c Osd_LanguageMenu.c Osd_IRABMenu.c Osd_RadioFreqMenu.c Osd_ResetMenu.c Osd_Menu.c Osd_FactoryMenu.c Osd_FactoryPicMenu.c Osd_FactorySwitchMenu.c
  group UserConfig
    ../../../UserConfig/: SystemConfig.h
  group Debug
    ../../../Debug/: Debug.c
  group FPVGoggles
    ../../../FPVGoggles/: channels.c Draw_osd.c BattAdc.c Buzzer.c
